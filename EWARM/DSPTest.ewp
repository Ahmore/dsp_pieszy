# IAR project DSPTest.ewp, settings and files
configuration DSPTest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: DSPTest.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: main.c stm32f7xx_it.c freertos.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_TIM.c
  group Application/EWARM
    ./:  startup_stm32f746xx.s
  group Middlewares
    ./: 
  group Middlewares/FreeRTOS
    ./: 
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c tasks.c list.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers
    ./: 
  group Drivers/STM32F7xx_HAL_Driver
    ./: 
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_uart.c stm32f7xx_hal_rng.c
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f7xx.c
